# Keil uVision project cmsis_spi_int_b2b_transfer_master.uvprojx, settings and files
target cmsis_spi_int_b2b_transfer_master debug (ARM-ADS)
  device: LPC54608J512ET180 NXP
  pack: Keil.LPC54000_DFP.2.4.0-dev0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: cmsis_spi_int_b2b_transfer_master.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_LPC54608, CPU_LPC54608J512ET180=1, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../../CMSIS/Driver/Include;../../../../..;../../../../../../../CMSIS/Include;../../../../../../../devices;../../../../../../../devices/LPC54608;../../../../../../../devices/LPC54608/drivers;../../../../../../../devices/LPC54608/drivers;../../../../../../../devices/LPC54608/drivers;../../../../../../../devices/LPC54608/cmsis_drivers;../../../../../../../devices/LPC54608/drivers;../../../../../../../devices/LPC54608/drivers;../../../../../../../devices/LPC54608/drivers;../../../../../../../devices/LPC54608/drivers;../../../../../../../devices/LPC54608/drivers;../../../../../../../devices/LPC54608/drivers;../../../../../../../devices/LPC54608;../../../../../../../devices/LPC54608/utilities/str;../../../../../../../devices/LPC54608/utilities/debug_console;../../../../../../../components/uart;../../../../../../../components/serial_manager;../../../../../../../components/lists;../../../../../../../components/serial_manager;../../../../../../../devices/LPC54608/drivers;../../../../../../../devices/LPC54608/drivers;../../../../../../../devices/LPC54608/drivers;../../../../../../../devices/LPC54608/drivers;../../../../../../../devices/LPC54608/drivers;../../../../../../../CMSIS/Driver/Include;../../../../../../../CMSIS/Driver/Include;../../../../../../../devices/LPC54608/utilities
  asm define: DEBUG,__CC_ARM,KEIL, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  scatter file: LPC54608J512_flash.scf
  link misc: ../../../../../../../devices/LPC54608/arm/keil_lib_power.lib --remove
  group source
    ../: cmsis_spi_int_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../devices/LPC54608/drivers/: fsl_dma.c fsl_dma.h fsl_spi.c fsl_spi.h fsl_spi_dma.c fsl_spi_dma.h fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h fsl_power.c fsl_power.h fsl_iocon.h fsl_inputmux.c fsl_inputmux.h fsl_inputmux_connections.h fsl_usart.c fsl_usart.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_emc.c fsl_emc.h fsl_reset.c fsl_reset.h
    ../../../../../../../devices/LPC54608/cmsis_drivers/: fsl_spi_cmsis.c fsl_spi_cmsis.h
  group device
    ../../../../../../../devices/LPC54608/: LPC54608.h LPC54608_features.h fsl_device_registers.h system_LPC54608.c system_LPC54608.h
  group utilities
    ../../../../../../../devices/LPC54608/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/LPC54608/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/LPC54608/utilities/: fsl_assert.c
  group component-uart
    ../../../../../../../components/uart/: uart.h usart_adapter.c
  group component-serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../../../devices/LPC54608/arm/: startup_LPC54608.s
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm4.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_SPI.h Driver_Common.h
target cmsis_spi_int_b2b_transfer_master release (ARM-ADS)
  device: LPC54608J512ET180 NXP
  pack: Keil.LPC54000_DFP.2.4.0-dev0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: cmsis_spi_int_b2b_transfer_master.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_LPC54608, CPU_LPC54608J512ET180=1, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: CPU_LPC54114J256_M4, NDEBUG,__CC_ARM,KEIL, NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC54608J512_flash.scf
  link misc: as above
