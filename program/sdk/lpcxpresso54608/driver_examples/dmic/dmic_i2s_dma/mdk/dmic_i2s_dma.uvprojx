# Keil uVision project dmic_i2s_dma.uvprojx, settings and files
target dmic_i2s_dma debug (ARM-ADS)
  device: LPC54608J512ET180 NXP
  pack: Keil.LPC54000_DFP.2.4.0-dev0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: dmic_i2s_dma.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_LPC54608, CPU_LPC54608J512ET180=1, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8904_ENABLE, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../..;..;../../../../../../platform/utilities/debug_console;../../../..;../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/LPC54608;../../../../../../components/i2c;../../../../../../devices/LPC54608/drivers;../../../../../../devices/LPC54608/drivers;../../../../../../devices/LPC54608/drivers;../../../../../../devices/LPC54608/drivers;../../../../../../devices/LPC54608/drivers;../../../../../../devices/LPC54608/drivers;../../../../../../devices/LPC54608/drivers;../../../../../../devices/LPC54608/drivers;../../../../../../components/codec/wm8904;../../../../../../components/codec;../../../../../../components/codec/port;../../../../../../devices/LPC54608/drivers;../../../../../../devices/LPC54608/drivers;../../../../../../devices/LPC54608/drivers;../../../../../../devices/LPC54608/drivers;../../../../../../devices/LPC54608/drivers;../../../../../../devices/LPC54608;../../../../../../devices/LPC54608/utilities/str;../../../../../../devices/LPC54608/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../components/serial_manager;../../../../../../devices/LPC54608/drivers;../../../../../../devices/LPC54608/drivers;../../../../../../devices/LPC54608/drivers;../../../../../../components/codec/i2c;../../../../../../devices/LPC54608/drivers;../../../../../../devices/LPC54608/utilities
  asm define: DEBUG,__CC_ARM,KEIL, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  scatter file: LPC54608J512_flash.scf
  link misc: ../../../../../../devices/LPC54608/arm/keil_lib_power.lib --remove
  group source
    ../: dmic_i2s_dma.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group component/i2c
    ../../../../../../components/i2c/: flexcomm_i2c_adapter.c i2c.h
  group drivers
    ../../../../../../devices/LPC54608/drivers/: fsl_iocon.h fsl_i2c.c fsl_i2c.h fsl_i2s.c fsl_i2s.h fsl_i2s_dma.c fsl_i2s_dma.h fsl_dmic.c fsl_dmic.h fsl_dmic_dma.c fsl_dmic_dma.h fsl_dma.c fsl_dma.h fsl_usart.c fsl_usart.h fsl_common.c fsl_common.h fsl_clock.c fsl_clock.h fsl_power.c fsl_power.h fsl_gpio.c fsl_gpio.h fsl_inputmux.c fsl_inputmux.h fsl_flexcomm.c fsl_flexcomm.h fsl_emc.c fsl_emc.h fsl_reset.c fsl_reset.h fsl_inputmux_connections.h
  group codec
    ../../../../../../components/codec/wm8904/: fsl_wm8904.c fsl_wm8904.h
    ../../../../../../components/codec/port/wm8904/: fsl_codec_adapter.c
    ../../../../../../components/codec/: fsl_codec_common.c fsl_codec_common.h
    ../../../../../../components/codec/port/: fsl_codec_adapter.h
    ../../../../../../components/codec/i2c/: fsl_codec_i2c.c fsl_codec_i2c.h
  group device
    ../../../../../../devices/LPC54608/: LPC54608.h LPC54608_features.h fsl_device_registers.h system_LPC54608.c system_LPC54608.h
  group utilities
    ../../../../../../devices/LPC54608/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/LPC54608/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/LPC54608/utilities/: fsl_assert.c
  group component-uart
    ../../../../../../components/uart/: uart.h usart_adapter.c
  group component-serial_manager
    ../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../../devices/LPC54608/arm/: startup_LPC54608.s
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm4.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
target dmic_i2s_dma release (ARM-ADS)
  device: LPC54608J512ET180 NXP
  pack: Keil.LPC54000_DFP.2.4.0-dev0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: dmic_i2s_dma.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_LPC54608, CPU_LPC54608J512ET180=1, SDK_I2C_BASED_COMPONENT_USED=1, BOARD_USE_CODEC=1, CODEC_WM8904_ENABLE, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: CPU_LPC54114J256_M4, NDEBUG,__CC_ARM,KEIL, NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC54608J512_flash.scf
  link misc: as above
