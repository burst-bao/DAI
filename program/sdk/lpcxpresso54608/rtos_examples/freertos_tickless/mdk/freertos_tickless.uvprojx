# Keil uVision project freertos_tickless.uvprojx, settings and files
target freertos_tickless debug (ARM-ADS)
  device: LPC54608J512ET180 NXP
  pack: Keil.LPC54000_DFP.2.4.0-dev0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: freertos_tickless.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_LPC54608, CPU_LPC54608J512ET180=1, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ../../../../../rtos/amazon-freertos/freertos_kernel/portable/GCC/ARM_CM4F;..;../low_power_tickless;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../devices/LPC54608;../../../../../rtos/amazon-freertos/freertos_kernel/include;../../../../../devices/LPC54608/drivers;../../../../../devices/LPC54608/drivers;../../../../../devices/LPC54608/drivers;../../../../../devices/LPC54608/drivers;../../../../../devices/LPC54608/drivers;../../../../../devices/LPC54608/drivers;../../../../../devices/LPC54608;../../../../../devices/LPC54608/utilities/str;../../../../../devices/LPC54608/utilities/debug_console;../../../../../components/uart;../../../../../components/serial_manager;../../../../../components/lists;../../../../../components/serial_manager;../../../../../devices/LPC54608/drivers;../../../../../devices/LPC54608/drivers;../../../../../devices/LPC54608/drivers;../../../../../devices/LPC54608/drivers;../../../../../devices/LPC54608/drivers;../../../../../devices/LPC54608/drivers;../../../../../devices/LPC54608/drivers;../../../../../devices/LPC54608/utilities
  asm define: DEBUG,__CC_ARM,KEIL, DEBUG
  asm include: ..;../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  scatter file: LPC54608J512_flash.scf
  link misc: ../../../../../devices/LPC54608/arm/keil_lib_power.lib --remove
  group source-low_power_tickless
    ../low_power_tickless/: fsl_tickless_rtc.c fsl_tickless_rtc.h
  group source
    ../: freertos_tickless.c FreeRTOSConfig.h
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/LPC54608/drivers/: fsl_rtc.c fsl_rtc.h fsl_pint.c fsl_pint.h fsl_clock.c fsl_clock.h fsl_power.c fsl_power.h fsl_inputmux.c fsl_inputmux.h fsl_common.c fsl_common.h fsl_usart.c fsl_usart.h fsl_flexcomm.c fsl_flexcomm.h fsl_iocon.h fsl_gpio.c fsl_gpio.h fsl_emc.c fsl_emc.h fsl_reset.c fsl_reset.h fsl_inputmux_connections.h
  group amazon-freertos-freertos_kernel-portable-MemMang
    ../../../../../rtos/amazon-freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group device
    ../../../../../devices/LPC54608/: LPC54608.h LPC54608_features.h fsl_device_registers.h system_LPC54608.c system_LPC54608.h
  group utilities
    ../../../../../devices/LPC54608/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/LPC54608/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/LPC54608/utilities/: fsl_assert.c
  group component-uart
    ../../../../../components/uart/: uart.h usart_adapter.c
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/LPC54608/arm/: startup_LPC54608.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
  group amazon-freertos-freertos_kernel
    ../../../../../rtos/amazon-freertos/freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos-freertos_kernel-include
    ../../../../../rtos/amazon-freertos/freertos_kernel/include/: FreeRTOS.h atomic.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group amazon-freertos-freertos_kernel-portable-GCC-ARM_CM4F
    ../../../../../rtos/amazon-freertos/freertos_kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group amazon-freertos-freertos_kernel-portable
    ../../../../../rtos/amazon-freertos/freertos_kernel/portable/: readme.txt
target freertos_tickless release (ARM-ADS)
  device: LPC54608J512ET180 NXP
  pack: Keil.LPC54000_DFP.2.4.0-dev0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: freertos_tickless.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_LPC54608, CPU_LPC54608J512ET180=1, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: CPU_LPC54114J256_M4, NDEBUG,__CC_ARM,KEIL, NDEBUG
  asm include: ..;../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC54608J512_flash.scf
  link misc: as above
